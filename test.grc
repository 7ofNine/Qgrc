options:
  parameters:
    author: Hartmuth Gutsche
    description: This GRC demo is for testing basic functionality
    generate_options: qt_gui
    id: basictest
    output_language: python
    title: Vector averaging and median comparison
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']

metadata:
  file_format: 1
  grc_version: g3259f3d9
